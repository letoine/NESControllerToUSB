# Repository letoine/NESControllerToUSB

File README.md:

NESControllerToUSB
==================

Simple adapter that transforms a NES controller into a USB controller.

## KiCad design hardware/NESControllerToUSB.kicad_pcb

Parts:
C1, C2: 22p
C3, C5: 100nf
C4: 1uf
CON1: AVR-ISP6; AVR-ISP-6
J1: USB
J2: NES_CONT_SOCKET
J3: SNES_CONT_SOCKET
R1, R2: 22ohms
R3: 10K
U1: ATMEGA32U2-AU
X1: 16Mhz

Connections:
CLOCK: J2.2 (CLOCK), J3.6 (CLOCK), U1.10
DATA0_PIN: J2.4 (DATA0), J3.4 (DATA0), U1.8
DATA1_PIN: J2.5 (DATA1), J3.3 (DATA1), U1.7
DATA2_PIN: J2.6 (DATA2), J3.2 (DATA2), U1.6
GND: C1.2, C2.2, C3.1, C4.1, C5.2, CON1.6 (GND), J1.4 (GND), J1.5 (Shield_1), J1.6 (Shield_2), J2.1 (GND), J3.1 (GND), U1.3, U1.28
LATCH: J2.3 (LATCH), J3.5 (LATCH), U1.9
MISO: CON1.1 (MISO), U1.17
MOSI: CON1.4 (MOSI), U1.16
unnamed: J1.3 (D+), R2.1
unnamed: C4.2, U1.27
unnamed: R1.2, U1.30
unnamed: J1.2 (D-), R1.1
unnamed: R2.2, U1.29
unnamed: C1.1, U1.1, X1.1
unnamed: C2.1, U1.2, X1.2
RESET: C5.1, CON1.5 (RST), R3.2, U1.24
SCK: CON1.3 (SCK), U1.15
VCC: C3.2, CON1.2 (VCC), J1.1 (Vbus), J2.7 (VCC), J3.7 (VCC), R3.1, U1.4, U1.31, U1.32

Board: 2 copper layers, 42.1 x 47.8 mm, 14 parts (0 on the bottom side), 18 nets.

## Code that names these connections

File software/Joystick.c:

#include "Joystick.h"

static uint8_t PrevJoystickHIDReportBuffer[sizeof(USB_JoystickReport_Data_t)];

USB_ClassInfo_HID_Device_t Joystick_HID_Interface = {
  .Config = {
    .InterfaceNumber = INTERFACE_ID_Joystick,
    .ReportINEndpoint = {
      .Address              = JOYSTICK_EPADDR,
      .Size                 = JOYSTICK_EPSIZE,
      .Banks                = 1,
    },
    .PrevReportINBuffer           = PrevJoystickHIDReportBuffer,
    .PrevReportINBufferSize       = sizeof(PrevJoystickHIDReportBuffer),
  },
};

#define IO_PORT	PORTD
#define IO_DDR	PORTD
#define IO_PIN	PIND

#define DATA2_PIN	0
#define DATA1_PIN	1
#define DATA0_PIN	2
#define LATCH_PIN	3
#define CLOCK_PIN	4

#define INPUT_PINS_MASK		(_BV(DATA0_PIN)|_BV(DATA1_PIN)|_BV(DATA2_PIN))
#define OUTPUT_PINS_MASK	(_BV(CLOCK_PIN)|_BV(LATCH_PIN))

inline void set_clock_high() {
  IO_PORT |= _BV(CLOCK_PIN);
}

inline void set_clock_low() {
  IO_PORT &= ~(_BV(CLOCK_PIN));
}

inline void set_latch_high() {
  IO_PORT |= _BV(LATCH_PIN);
}

inline void set_latch_low() {
  IO_PORT &= ~(_BV(LATCH_PIN));
}

inline bool is_data0_low() {
  return !(IO_PIN & _BV(DATA0_PIN));
}

inline bool is_data1_low() {
  return !(IO_PIN & _BV(DATA1_PIN));
}

inline bool is_data2_low() {
  return !(IO_PIN & _BV(DATA2_PIN));
}

inline void toggle_clock() {
  set_clock_high();
  _delay_ms(1);
  set_clock_low();
}

int main(void) {
  SetupHardware();
  
  GlobalInterruptEnable();
  
  for (;;) {
    HID_Device_USBTask(&Joystick_HID_Interface);
    USB_USBTask();
  }
}

void SetupHardware(void) {
  /* Disable watchdog if enabled by bootloader/fuses */
  MCUSR &= ~(1 << WDRF);
  wdt_disable();
  
  /* Disable clock division */
  clock_prescale_set(clock_div_1);
  
  /* Hardware Initialization */
  /* Port B pins for clock and latch are set to output */
  IO_DDR = OUTPUT_PINS_MASK;
  /* Set pull-up ressitors for inputs */
  IO_PORT = INPUT_PINS_MASK;
  
  SerialDebug_init();
  USB_Init();
}

void EVENT_USB_Device_ConfigurationChanged(void) {
  bool ConfigSuccess = true;
  
  SerialDebug_printf("EVENT_USB_Device_ConfigurationChanged\r\n");
  ConfigSuccess &= HID_Device_ConfigureEndpoints(&Joystick_HID_Interface);
  
  USB_Device_EnableSOFEvents();
}

void EVENT_USB_Device_ControlRequest(void) {
  SerialDebug_printf("EVENT_USB_Device_ControlRequest\r\n");
  HID_Device_ProcessControlRequest(&Joystick_HID_Interface);
}

void EVENT_USB_Device_StartOfFrame(void) {
  //SerialDebug_printf("EVENT_USB_Device_StartOfFrame\r\n");
  HID_Device_MillisecondElapsed(&Joystick_HID_Interface);
}

bool CALLBACK_HID_Device_CreateHIDReport(USB_ClassInfo_HID_Device_t* const HIDInterfaceInfo,
                                         uint8_t* const ReportID,
                                         const uint8_t ReportType,
                                         void* ReportData,
                                         uint16_t* const ReportSize)
{
  USB_JoystickReport_Data_t* JoystickReport = (USB_JoystickReport_Data_t*)ReportData;
  
  set_clock_high();
  set_latch_high();

  JoystickReport->Y = 0;
  JoystickReport->X = 0;
  JoystickReport->button.raw[0] = 0;
  JoystickReport->button.raw[1] = 0;
  
  set_latch_low();
  
  toggle_clock();
  if (is_data0_low()) // B
    JoystickReport->button.cross = 1;
  
  toggle_clock();
  if (is_data0_low()) // Y
    JoystickReport->button.square =  1;
  
  toggle_clock();
  if (is_data0_low()) // Select
    JoystickReport->button.select = 1;
  
  toggle_clock();
  if (is_data0_low()) // Start
    JoystickReport->button.start = 1;
  
  toggle_clock();
  if (is_data0_low()) // up
    JoystickReport->Y = -127;
  
  toggle_clock();
  if (is_data0_low()) // down
    JoystickReport->Y = 127;
  
  toggle_clock();
  if (is_data0_low()) // left
    JoystickReport->X = -127;
  
  toggle_clock();
  if (is_data0_low()) // right
    JoystickReport->X = 127;
  
  toggle_clock();
  if (is_data0_low()) // A
    JoystickReport->button.circle = 1;
  
  toggle_clock();
  if (is_data0_low()) // X
    JoystickReport->button.triangle = 1;
  
  toggle_clock();
  if (is_data0_low()) // L
    JoystickReport->button.l1 = 1;
  
  toggle_clock();
  if (is_data0_low()) // R
    JoystickReport->button.r1 = 1;
  
  toggle_clock();
  toggle_clock();
  toggle_clock();
  _delay_ms(6);
  set_clock_high();
  
  *ReportSize = sizeof(USB_JoystickReport_Data_t);
  return false;
}

void CALLBACK_HID_Device_ProcessHIDReport(USB_ClassInfo_HID_Device_t* const HIDInterfaceInfo,
                                          const uint8_t ReportID,
                                          const uint8_t ReportType,
                                          const void* ReportData,
                                          const uint16_t ReportSize)
{
  SerialDebug_printf("CALLBACK_HID_Device_ProcessHIDReport\r\n");
  SerialDebug_printf("%#0x, %#0x\r\n", ReportID, ReportType);
  SerialDebug_printByteArray(ReportData, ReportSize);
  
  // Unused (but mandatory for the HID class driver) in this demo, since there are no Host->Device reports
}

## Commit log

2014-11-10 Adding code for firmware. Works nice with teensy and NES controller. need test with snes.
2014-11-16 Adding schematics for board. Adding NES ans SNES controller socket, need to check proper dimentions whan having the socken in hands.

Notices in the files:
hardware/NESControllerToUSB.kicad_pcb:
Copyright 2014 antoine terrienne
